# Keil uVision project test.uvprojx, settings and files
target test (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: test +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bincombined "!L" --output="$L\M115.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT=1U,__FPU_USED=1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\BSP;..\Protocol;..\Utils;..\module;..\PMSM;..\Brush
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../BSP/: adc.c dma.c gpio.c can.c tim.c usart.c led_driver.c QMI8658C.c bsp_flash.c arm_cortexM4lf_math.lib
  group Utils
    ../Utils/: crc.c key_filter.c pid.c utils_queue.c filter.c
  group Protocol
    ../Protocol/: alloc.c protocol.c protocol_api.c protocol_register_management.c rt_malloc.c xsto_api_ii.c
  group Modlue
    ../module/: adc_callback.c led.c serial_debug.c Status_Check.c task.c weak_handle.c
    ../Module/: CurveProgramme.c Scurve.c ultrasonic.c
  group PMSM
    ../PMSM/: FOC.c HALL_Encoder.c PLL.c PMSM_Calib.c PMSM_Control.c PMSM_Driver.c
  group Brush
    ../Brush/: Brush_Calib.c Brush_Control.c Brush_Driver.c
software components: CMSIS:CORE 4.3.0
