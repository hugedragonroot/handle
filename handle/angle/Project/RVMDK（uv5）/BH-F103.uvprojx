# Keil uVision project BH-F103.uvprojx, settings and files
target AngleCtrl-Core (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bincombined "!L" --output="$L\xsto_angle.bin"
  c flags: Optim=1 uC99=1 wLevel=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c
    ../../User/RTC/: bsp_rtc.c
    ../../User/I2C/: bsp_i2c.c
    ../../User/ADC/: bsp_adc.c
    ../../User/CAN/: bsp_can.c
    ../../User/Gpio/: bsp_gpio.c
    ../../User/wwdg/: bsp_wwdg.c
    ../../User/Sysclk/: bsp_Sysclk.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/ATusart/: bsp_ATusart.c
    ../../User/TimBase/: bsp_TiMbase.c
    ../../User/Internal_flash/: bsp_internal_flash.c
    ../../User/QMI8658C/: qmi8658c.c
  group App
    ../../App/: app_led.c app_angle.c app_loopqueue.c app_protocol.c app_kalman.c
