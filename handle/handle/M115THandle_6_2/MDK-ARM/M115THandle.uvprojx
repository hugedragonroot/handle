# Keil uVision project M115THandle.uvprojx, settings and files
target M115T_Handle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: M115T_Handle +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\GD32F30x_Firmware_Library\CMSIS;..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\MAIN;..\APP;..\DRV;..\DEBUG;..\EXT;..\GD32F30x_Firmware_Library\Third_party\FreeRTOSv10.3.1\Source\include;..\GD32F30x_Firmware_Library\Third_party\FreeRTOSv10.3.1\Source\portable\RVDS\ARM_CM4F;..\COMMON;..\TASK;..\PROTOCOL\protocol_427;..\PROTOCOL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MAIN
    ../MAIN/: main.c main.h gd32f30x_it.c delay.c
  group TASK
    ../TASK/: data_pack_task.c display_task.c key_task.c wirelink_task.c BTlink_task.c commandTx_task.c gps_task.c CAN_task.c
  group CMSIS
    ../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group APP
    ../APP/: app_bmp.c app_bmp.h app_display.c app_display.h app_loopqueue.c app_loopqueue.h app_mem.c app_mem.h app_protocol.c app_protocol.h app_remote_para.c app_remote_para.h
  group DRV
    ../DRV/: bt_drv.c bt_drv.h buzz_drv.c buzz_drv.h drv.c drv.h joystick_drv.c joystick_drv.h key_drv.c key_drv.h lcd_drv.c lcd_drv.h uart_drv.c uart_drv.h gps_drv.c gps_drv.h rf_315m_drv.c rf_315m_drv.h music_drv.c music_drv.h led_drv.c led_drv.h power_control.c ev1527_drv.c
  group EXT
    ../EXT/: bt_ext.c bt_ext.h buzz_ext.c buzz_ext.h ext.c ext.h flash_ext.c flash_ext.h joystick_ext.c joystick_ext.h key_ext.c key_ext.h lcd_ext.c lcd_ext.h timer_ext.c timer_ext.h uart_ext.c uart_ext.h rf_315m_ext.c rf_315m_ext.h music_ext.c music_ext.h led_ext.c led_ext.h gps_ext.c gps_ext.h can_ext.c can_ext.h fwdgt_ext.c fwdgt_ext.h ev1527_ext.c
  group DEBUG
    ../DEBUG/: debug.c debug.h
  group Doc
    ../MAIN/: readme.txt
  group FreeRTOS
    ../GD32F30x_Firmware_Library/Third_party/FreeRTOSv10.3.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../GD32F30x_Firmware_Library/Third_party/FreeRTOSv10.3.1/Source/portable/MemMang/: heap_4.c
    ../GD32F30x_Firmware_Library/Third_party/FreeRTOSv10.3.1/Source/portable/RVDS/ARM_CM4F/: port.c
  group COMMON
    ../PROTOCOL/protocol_427/: protocol_register_management.c
    ../COMMON/: freeRTOSdebug.c FreeRTOSConfig.h
  group PROTOCOL
    ../PROTOCOL/protocol_427/: alloc.c crc.c protocol.c protocol_api.c rt_malloc.c xsto_api_ii.c
software components: CMSIS:CORE 5.4.0
